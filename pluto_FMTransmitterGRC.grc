options:
  parameters:
    author: quinnten-hatfield
    generate_options: qt_gui
    id: pluto_FMTransmitterGRC
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: attenuation
  id: variable_qtgui_range
  parameters:
    label: '"Attentuation Changer"'
    start: '0'
    step: '1'
    stop: '100'
    value: '45'
  states: {}
- name: bandwidth
  id: variable
  parameters:
    value: '200000'
  states: {}
- name: decim
  id: variable
  parameters:
    value: '1'
  states: {}
- name: interp
  id: variable
  parameters:
    value: '5'
  states: {}
- name: pluto_samp_rate
  id: variable
  parameters:
    value: '2400000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: analog_wfm_tx_0
  id: analog_wfm_tx
  parameters:
    audio_rate: samp_rate
    fh: '-1.0'
    max_dev: 75e3
    quad_rate: samp_rate * 10
    tau: '75e-6'
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    device_name: '"pipewire"'
    samp_rate: samp_rate
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: attenuation
    bandwidth: bandwidth
    buffer_size: '32768'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: int(99.5e6)
    samplerate: pluto_samp_rate
    type: fc32
    uri: ip:192.168.2.1
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '15000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '3000'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: pluto_samp_rate
    fc: int(99.5e6)
    fftsize: '1024'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: decim
    interp: interp
    type: ccc
  states: {}

connections:
- [analog_wfm_tx_0, '0', rational_resampler_xxx_0, '0']
- [audio_source_0, '0', low_pass_filter_0, '0']
- [low_pass_filter_0, '0', analog_wfm_tx_0, '0']
- [rational_resampler_xxx_0, '0', iio_pluto_sink_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
