options:
  parameters:
    generate_options: qt_gui
    id: pluto_FM_TxAndRx
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: attenuation
  id: variable_qtgui_range
  parameters:
    label: '"Attentuation Changer"'
    start: '0'
    step: '1'
    stop: '89'
    value: '88'
  states: {}
- name: audio_decim
  id: variable
  parameters:
    value: '4'
  states: {}
- name: bandwidth
  id: variable
  parameters:
    value: '200000'
  states: {}
- name: decim
  id: variable
  parameters:
    value: '1'
  states: {}
- name: deviation
  id: variable
  parameters:
    value: '75000'
  states: {}
- name: interp
  id: variable
  parameters:
    value: '3'
  states: {}
- name: interp_0
  id: variable
  parameters:
    value: '5'
  states: {}
- name: pluto_samp_rate
  id: variable
  parameters:
    value: '2400000'
  states: {}
- name: rf_decim
  id: variable
  parameters:
    value: '32'
  states: {}
- name: rx_check
  id: variable_qtgui_check_box
  parameters:
    'false': '0'
    label: '"Receive and Listen"'
    'true': '1'
    type: int
    value: rx_enable
  states: {}
- name: rx_enable
  id: variable
  parameters:
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(2.048e6)
  states: {}
- name: tuning
  id: variable_qtgui_range
  parameters:
    label: '"Station Frequency"'
    rangeType: int
    start: int(81.1e6)
    step: int(0.1e6)
    stop: int(107.9e6)
    value: int(101.9e6)
  states: {}
- name: tx_check
  id: variable_qtgui_check_box
  parameters:
    'false': '0'
    label: '"Start Transmitting"'
    'true': '1'
    type: int
    value: tx_enable
  states: {}
- name: tx_enable
  id: variable
  parameters:
    value: '0'
  states: {}
- name: tx_samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: tx_tuning
  id: variable_qtgui_range
  parameters:
    label: '"Tx Station Frequency"'
    rangeType: int
    start: int(81.1e6)
    step: int(0.1e6)
    stop: int(107.9e6)
    value: int(99.9e6)
  states: {}
- name: variable_0
  id: variable
  parameters:
    value: '0'
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    label: Volume
    start: '0'
    step: '50e-3'
    stop: '1'
    value: '300e-3'
  states: {state: disabled}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: audio_decim
    quad_rate: 192e3
  states: {}
- name: analog_wfm_tx_0
  id: analog_wfm_tx
  parameters:
    audio_rate: tx_samp_rate
    fh: '-1.0'
    max_dev: 75e3
    quad_rate: tx_samp_rate  * 10
    tau: '75e-6'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    device_name: device
    samp_rate: '48000'
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    device_name: '"pipewire"'
    samp_rate: tx_samp_rate
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: tx_check
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {}
- name: blocks_selector_1
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: '0'
    num_inputs: '1'
    num_outputs: '2'
    output_index: rx_check
    type: float
  states: {}
- name: device
  id: parameter
  parameters:
    label: Device Name
    type: str
    value: default
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: attenuation
    bandwidth: bandwidth
    buffer_size: '32768'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: int(tx_tuning)
    samplerate: pluto_samp_rate
    type: fc32
    uri: ip:192.168.2.1
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: tuning
    gain1: '''slow_attack'''
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate
    type: fc32
    uri: ip:192.168.2.1
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '15000'
    decim: '1'
    gain: '1'
    samp_rate: tx_samp_rate
    type: fir_filter_fff
    width: '3000'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: tx_samp_rate
    fc: int(tx_tuning)
    fftsize: '1024'
    name: '"Transmitted Signal"'
    type: complex
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: tuning
    fftsize: '1024'
    name: '"Receive Signal"'
    showrf: 'True'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: rf_decim
    interp: interp
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: decim
    interp: interp_0
    type: ccc
  states: {}

connections:
- [analog_wfm_rcv_0, '0', blocks_selector_1, '0']
- [analog_wfm_tx_0, '0', rational_resampler_xxx_0_0, '0']
- [audio_source_0, '0', low_pass_filter_0, '0']
- [blocks_null_source_0, '0', blocks_selector_0, '0']
- [blocks_selector_0, '0', iio_pluto_sink_0, '0']
- [blocks_selector_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_selector_1, '0', blocks_null_sink_0, '0']
- [blocks_selector_1, '1', audio_sink_0, '0']
- [iio_pluto_source_0, '0', rational_resampler_xxx_0, '0']
- [low_pass_filter_0, '0', analog_wfm_tx_0, '0']
- [rational_resampler_xxx_0, '0', analog_wfm_rcv_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_sink_x_0, '0']
- [rational_resampler_xxx_0_0, '0', blocks_selector_0, '1']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
